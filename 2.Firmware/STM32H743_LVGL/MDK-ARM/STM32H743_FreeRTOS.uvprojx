# Keil uVision project STM32H743_FreeRTOS.uvprojx, settings and files
target STM32H743_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H743_FreeRTOS +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,LV_LVGL_H_INCLUDE_SIMPLE,LV_CONF_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../User/Driver/LCD;../User/APP;../User/Driver/Bsp_ESP8266;../User/Driver/Bsp_Uart;../User/APP/LVGL;../User/APP/LVGL/src;../User/APP/LVGL/porting;../User/APP/LVGL/demos/benchmark;..\User\APP\LVGL\generated;..\User\APP\LVGL\generated\guider_customer_fonts;..\User\APP\LVGL\generated\guider_fonts;..\User\APP\LVGL\src\font
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fmc.c mdma.c quadspi.c spi.c tim.c usart.c usb_otg.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group User/APP/Task
    ../User/APP/: LCD_Task.c KEY_Task.c Network_Task.c
  group User/Drive/UART
    ../User/Driver/Bsp_Uart/: Bsp_Uart.c Fifo.c
  group User/Drive/ESP8266
    ../User/Driver/Bsp_ESP8266/: Bsp_ESP8266.c cString.c Network.c
  group User/LCD
    ../User/Driver/LCD/: bsp_st7735s.c st7735s.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nand.c stm32h7xx_hal_qspi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lvgl
    ../User/APP/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../User/APP/LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../User/APP/LVGL/src/draw/nxp/: lv_gpu_nxp.c
    ../User/APP/LVGL/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_gpu_nxp_vglite.c
    ../User/APP/LVGL/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../User/APP/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../User/APP/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../User/APP/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../User/APP/LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../User/APP/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../User/APP/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../User/APP/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../User/APP/LVGL/src/layouts/flex/: lv_flex.c
    ../User/APP/LVGL/src/layouts/grid/: lv_grid.c
    ../User/APP/LVGL/src/libs/bmp/: lv_bmp.c
    ../User/APP/LVGL/src/libs/ffmpeg/: lv_ffmpeg.c
    ../User/APP/LVGL/src/libs/freetype/: lv_freetype.c
    ../User/APP/LVGL/src/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../User/APP/LVGL/src/libs/gif/: gifdec.c lv_gif.c
    ../User/APP/LVGL/src/libs/png/: lodepng.c lv_png.c
    ../User/APP/LVGL/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../User/APP/LVGL/src/libs/rlottie/: lv_rlottie.c
    ../User/APP/LVGL/src/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../User/APP/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_malloc_builtin.c lv_math.c lv_mem.c lv_memcpy_builtin.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../User/APP/LVGL/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../User/APP/LVGL/src/others/gridnav/: lv_gridnav.c
    ../User/APP/LVGL/src/others/ime/: lv_ime_pinyin.c
    ../User/APP/LVGL/src/others/imgfont/: lv_imgfont.c
    ../User/APP/LVGL/src/others/monkey/: lv_monkey.c
    ../User/APP/LVGL/src/others/msg/: lv_msg.c
    ../User/APP/LVGL/src/others/snapshot/: lv_snapshot.c
    ../User/APP/LVGL/src/themes/basic/: lv_theme_basic.c
    ../User/APP/LVGL/src/themes/default/: lv_theme_default.c
    ../User/APP/LVGL/src/themes/mono/: lv_theme_mono.c
    ../User/APP/LVGL/src/widgets/animimg/: lv_animimg.c
    ../User/APP/LVGL/src/widgets/arc/: lv_arc.c
    ../User/APP/LVGL/src/widgets/bar/: lv_bar.c
    ../User/APP/LVGL/src/widgets/btn/: lv_btn.c
    ../User/APP/LVGL/src/widgets/btnmatrix/: lv_btnmatrix.c
    ../User/APP/LVGL/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../User/APP/LVGL/src/widgets/canvas/: lv_canvas.c
    ../User/APP/LVGL/src/widgets/chart/: lv_chart.c
    ../User/APP/LVGL/src/widgets/checkbox/: lv_checkbox.c
    ../User/APP/LVGL/src/widgets/colorwheel/: lv_colorwheel.c
    ../User/APP/LVGL/src/widgets/dropdown/: lv_dropdown.c
    ../User/APP/LVGL/src/widgets/img/: lv_img.c
    ../User/APP/LVGL/src/widgets/imgbtn/: lv_imgbtn.c
    ../User/APP/LVGL/src/widgets/keyboard/: lv_keyboard.c
    ../User/APP/LVGL/src/widgets/label/: lv_label.c
    ../User/APP/LVGL/src/widgets/led/: lv_led.c
    ../User/APP/LVGL/src/widgets/line/: lv_line.c
    ../User/APP/LVGL/src/widgets/list/: lv_list.c
    ../User/APP/LVGL/src/widgets/menu/: lv_menu.c
    ../User/APP/LVGL/src/widgets/meter/: lv_meter.c
    ../User/APP/LVGL/src/widgets/msgbox/: lv_msgbox.c
    ../User/APP/LVGL/src/widgets/objx_templ/: lv_objx_templ.c
    ../User/APP/LVGL/src/widgets/roller/: lv_roller.c
    ../User/APP/LVGL/src/widgets/slider/: lv_slider.c
    ../User/APP/LVGL/src/widgets/span/: lv_span.c
    ../User/APP/LVGL/src/widgets/spinbox/: lv_spinbox.c
    ../User/APP/LVGL/src/widgets/spinner/: lv_spinner.c
    ../User/APP/LVGL/src/widgets/switch/: lv_switch.c
    ../User/APP/LVGL/src/widgets/table/: lv_table.c
    ../User/APP/LVGL/src/widgets/tabview/: lv_tabview.c
    ../User/APP/LVGL/src/widgets/textarea/: lv_textarea.c
    ../User/APP/LVGL/src/widgets/tileview/: lv_tileview.c
    ../User/APP/LVGL/src/widgets/win/: lv_win.c
  group Lvgl_Port
    ../User/APP/LVGL/porting/: lv_port_disp.c lv_port_indev.c
    ../User/APP/LVGL/: lv_conf.h lvgl.h
  group Lvgl_Demo
    ../User/APP/LVGL/demos/benchmark/: lv_demo_benchmark.c
    ../User/APP/LVGL/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
software components: CMSIS:CORE 5.6.0
