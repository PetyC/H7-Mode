# Keil uVision project H7_Core.uvprojx, settings and files
target H7_Core (6160000::V6.16::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: H7_Core
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\STM32CubeMX\STCubeGenerated\Inc;.\User\Driver\include;.\User\APP\include;.\RTE\File_System;.\User\KEIL_HardFaulthandler;.\User\Lvgl;.\User\Lvgl\src;.\User\Lvgl\porting;.\User\Lvgl\GUI;.\User\Lvgl\GUI\custom;.\User\Lvgl\GUI\guider_customer_fonts;.\User\Lvgl\GUI\guider_fonts;.\User\Lvgl\GUI\images;.\User\Lvgl\src\font;.\User\Lvgl\demos\benchmark\assets;.\User\Lvgl\demos\benchmark
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group :STM32CubeMX:Common Sources
    ./STM32CubeMX/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./STM32CubeMX/STCubeGenerated/Inc/: stm32h7xx_it.h
  group APP
    ./User/APP/scr/: Freertos_Init.c LED_Task.c Uart_Task.c Test_Task.c User_FlashFS.c USBD_User_MSC_0.c LCD_Task.c Network_Task.c
  group Driver
    ./User/Driver/src/: Bsp_Nand_Flash.c Bsp_Uart.c Bsp_Uart_Fifo.c Bsp_w25qxx.c Bsp_st7735s.c Bsp_st7735s_interface.c
  group Segger
    ./User/Segger/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group HAL
    ./STM32CubeMX/STCubeGenerated/Src/: dma.c fmc.c gpio.c mdma.c quadspi.c spi.c tim.c usart.c usb_otg.c
  group Lvgl
    ./User/Lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./User/Lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./User/Lvgl/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ./User/Lvgl/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    ./User/Lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ./User/Lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ./User/Lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ./User/Lvgl/src/extra/: lv_extra.c
    ./User/Lvgl/src/extra/layouts/flex/: lv_flex.c
    ./User/Lvgl/src/extra/layouts/grid/: lv_grid.c
    ./User/Lvgl/src/extra/libs/bmp/: lv_bmp.c
    ./User/Lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./User/Lvgl/src/extra/libs/freetype/: lv_freetype.c
    ./User/Lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./User/Lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./User/Lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ./User/Lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./User/Lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ./User/Lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./User/Lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ./User/Lvgl/src/extra/others/monkey/: lv_monkey.c
    ./User/Lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ./User/Lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./User/Lvgl/src/extra/themes/default/: lv_theme_default.c
    ./User/Lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./User/Lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./User/Lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./User/Lvgl/src/extra/widgets/chart/: lv_chart.c
    ./User/Lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./User/Lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./User/Lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./User/Lvgl/src/extra/widgets/led/: lv_led.c
    ./User/Lvgl/src/extra/widgets/list/: lv_list.c
    ./User/Lvgl/src/extra/widgets/menu/: lv_menu.c
    ./User/Lvgl/src/extra/widgets/meter/: lv_meter.c
    ./User/Lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./User/Lvgl/src/extra/widgets/span/: lv_span.c
    ./User/Lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./User/Lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./User/Lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./User/Lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./User/Lvgl/src/extra/widgets/win/: lv_win.c
    ./User/Lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./User/Lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./User/Lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./User/Lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Lvgl_Port
    ./User/Lvgl/porting/: lv_port_disp.c lv_port_indev.c
    ./User/Lvgl/: lv_conf.h lvgl.h
  group Lvgl_GUI
    ./User/Lvgl/GUI/: events_init.c events_init.h gui_guider.c gui_guider.h setup_scr_device_screen.c setup_scr_main_screen.c setup_scr_QR_screen.c setup_scr_Wifi_screen.c
  group Lvgl_GUI_Custom
    ./User/Lvgl/GUI/custom/: custom.c
  group Lvgl_GUI_images
    ./User/Lvgl/GUI/images/: _QR_100x100.c _WIFI_con_15x14.c _WIFI_discon_15x14.c
  group Lvgl_GUI_guider_fonts
    ./User/Lvgl/GUI/guider_fonts/: guider_fonts.h lv_font_simsun_8.c lv_font_simsun_12.c
  group Lvgl_Demo
    ./User/Lvgl/demos/benchmark/: lv_demo_benchmark.c lv_demo_benchmark.h
    ./User/Lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
software components: RTOS:Config 10.4.6, RTOS:Core 10.4.6, RTOS:Event Groups 10.4.6, RTOS:Heap 10.4.6, RTOS:Timers 10.4.6, CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.4.6, Compiler:Event Recorder 1.5.1, Compiler:I/O:File 1.2.0, Compiler:I/O:STDOUT 1.2.0, File System:CORE 6.15.0, File System:Drive:NAND 6.15.0, USB:CORE 6.16.0, USB:Device 6.16.0, USB:Device:MSC 6.16.0, CMSIS Driver:NAND:Memory Bus 1.1.0, CMSIS Driver:USB Device 1.5.0, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:MDMA 1.9.0, Device:STM32Cube HAL:NAND 1.9.0, Device:STM32Cube HAL:PCD 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:QSPI 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:SPI 1.9.0, Device:STM32Cube HAL:TIM 1.9.0, Device:STM32Cube HAL:UART 1.9.0, Device:Startup 1.9.0
